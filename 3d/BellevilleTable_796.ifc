Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-01-15T10:26:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 15 10:26:16 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{FC08612F-F66B-4DF6-884E-6BCC4FB02363}\ifc * Database version: 5507 * Database creation date: Tue Jan 15 10:26:14 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jan 15 10:26:14 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 15 10:26:14 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Belleville Table ⌀796 Bistro - 12 mm board, CONV_Vitra_DiningTbls_BellevilleTable_796:Belleville Table ⌀796 Bistro - 12 mm board:312305
In: Level 1
Material: 01 white (textured), 12 powder coating deep black, Plastic, Opaque Black
Pset_ManufacturerTypeInformation - ModelReference: 44300800; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.79498 m2; Volume: 0.462223 m3
Materials and Finishes - TableMainMaterial: 01 white (textured)
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DiningTbls_BellevilleTable_796: Belleville Table ⌀796 Bistro - 12 mm board; Family and Type: CONV_Vitra_DiningTbls_BellevilleTable_796: Belleville Table ⌀796 Bistro - 12 mm board; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DiningTbls_BellevilleTable_796: Belleville Table ⌀796 Bistro - 12 mm board; Type Id: CONV_Vitra_DiningTbls_BellevilleTable_796: Belleville Table ⌀796 Bistro - 12 mm board; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Construction(Type) - BoardThickness: 12 mm
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DiningTbls_BellevilleTable_796; ConvergoRefNr: 0089-1812-0170-CH; ManufacturerName: Vitra; ManufacturerURL: www.vitra.com; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: The elegant Belleville Table by Ronan and Erwan Bouroullec comes in a number of different variations modelled on the classic bistro table. The smaller bistro tables, with round or square tops, are available in different versions, some suited for both indoor and outdoor use. The Belleville Table also comes with a rectangular top in various widths and lengths.; Revision: n/a; Uniclass2: Pr_40_50_21_21; Uniclass2015Description: Dining tables; Uniclass2015Reference: Pr_40_50_21_22; Version: 1; VersionDate: 20/12/2018
Identity Data(Type) - Cost: 0; Description: The elegant Belleville Table by Ronan and Erwan Bouroullec comes in a number of different variations modelled on the classic bistro table. The smaller bistro tables, with round or square tops, are available in different versions, some suited for both indoor and outdoor use. The Belleville Table also comes with a rectangular top in various widths and lengths.; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Belleville Table ⌀796 Bistro - 12 mm board; OmniClass Number: 23.40.20.14.17.11; OmniClass Title: Dining Room Tables; ProductDatasheet: https://www.vitra.com/en-gb/_storage/asset/1020281/storage/master/download/FS_Belleville_Table-EN_Preview-Single-Page.pdf; Type Name: Belleville Table ⌀796 Bistro - 12 mm board; URL: https://www.vitra.com/en-gb/product/belleville-table
Materials and Finishes(Type) - TableSecondaryMaterial: 12 powder coating deep black; TableTertiaryMaterial: Plastic, Opaque Black
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DiningTbls_BellevilleTable_796; Features: n/a; Finish: Solid core material with black edge (12 mm) in the colours white or black; Grade: n/a; Material: Plastic; ModelNumber: n/a; ModelReference: 44300800; Name: DiningTbls_BellevilleTable_796; ReplacementCost: n/a; Shape: Rectangular; Size: 796x796x730 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
